# Keil uVision project main_pin_functions.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main_pin_functions +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c wiring_private.h pins_arduino.h pins_arduino.c wiring_digital.c Arduino.h wiring.c print.h print.c stream.h stream.c main.h SPI.cpp SPI.h
software components: Device:Startup 2.2.0i
